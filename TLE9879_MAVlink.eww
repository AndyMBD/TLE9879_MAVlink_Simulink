<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TLE9879QXA40_DMA_UART_TTY\TLE9879QXA40_DMA_UART_TTY.ewp</path>
    </project>
    <batchBuild />
</workspace>
