# Keil uVision project TLE9879QXA40_DMA_UART_TTY.uvprojx, settings and files
target TLE9879_EvalKit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.4.1
  cpu: IRAM(0x18000018,0x17E8) IRAM2(0x18000000,0x10) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMA_UART_TTY
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x1004
  memory RVCT9: RAM 0x18000018 size 0x17e8
  memory RVCT10: RAM 0x18000000 size 0x10
  group App
    ./app/: main.c
software components: CMSIS:CORE 5.1.2, Device:ConfigWizard_v2 2.1.12, Device:SDK:BOOTROM 0.2.4, Device:SDK:DMA 0.1.4, Device:SDK:GPT12E 0.1.5, Device:SDK:INT 0.1.8, Device:SDK:ISR 0.2.4, Device:SDK:LIN 0.1.7, Device:SDK:MON 0.1.3, Device:SDK:PMU 0.1.7, Device:SDK:PORT 0.5.5, Device:SDK:SCU 0.3.6, Device:SDK:UART 0.1.6, Device:SDK:WDT1 0.2.8, Device:Startup 1.0.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
