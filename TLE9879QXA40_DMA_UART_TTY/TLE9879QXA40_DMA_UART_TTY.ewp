# IAR project TLE9879QXA40_DMA_UART_TTY.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TLE9879 Infineon TLE9879
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; app\Mavlink; app\Mavlink\TLE9879_MAVlink
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: TLE9879QXA40_DMA_UART_TTY.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group app
    app/: main.c Sin_Table.h write.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device.SDK WDT1
    RTE/Device/TLE9879QXA40/: wdt1.c wdt1.h
  group CMSIS-Pack/Device.SDK UART
    RTE/Device/TLE9879QXA40/: uart.c uart.h
  group CMSIS-Pack/Device.SDK SCU
    RTE/Device/TLE9879QXA40/: scu.c scu.h
  group CMSIS-Pack/Device.SDK PORT
    RTE/Device/TLE9879QXA40/: port.c port.h
  group CMSIS-Pack/Device.SDK PMU
    RTE/Device/TLE9879QXA40/: pmu.c pmu.h
  group CMSIS-Pack/Device.SDK MON
    RTE/Device/TLE9879QXA40/: mon.c mon.h
  group CMSIS-Pack/Device.SDK LIN
    RTE/Device/TLE9879QXA40/: lin.c lin.h
  group CMSIS-Pack/Device.SDK ISR
    RTE/Device/TLE9879QXA40/: isr.c isr.h
  group CMSIS-Pack/Device.SDK INT
    RTE/Device/TLE9879QXA40/: int.c int.h
  group CMSIS-Pack/Device.SDK GPT12E
    RTE/Device/TLE9879QXA40/: gpt12e.c gpt12e.h
  group CMSIS-Pack/Device.SDK DMA
    RTE/Device/TLE9879QXA40/: dma.c dma.h
  group CMSIS-Pack/Device.SDK BOOTROM
    RTE/Device/TLE9879QXA40/: bootrom.c bootrom.h
  group CMSIS-Pack/Device Startup
    RTE/Device/TLE9879QXA40/: cmsis_misra.h eval_board.h sfr_access.h startup_tle987x.s system_tle987x.c system_tle987x.h tle987x.h tle_device.c tle_device.h tle_variants.h types.h
  group CMSIS-Pack/Device ConfigWizard_v2
    RTE/Device/TLE9879QXA40/: adc1_defines.h adc2_defines.h bdrv_defines.h bsl_defines.h ccu6_defines.h config.icwp csa_defines.h dma_defines.h gpt12e_defines.h ICW_TLE987x.xml int_defines.h isr_defines.h lin_defines.h mon_defines.h pmu_defines.h port_defines.h scu_defines.h ssc_defines.h timer2x_defines.h timer3_defines.h TLE987x.mig TLE987x.svd uart_defines.h
  group MAVlink
    app/Mavlink/: checksum.h mavlink_conversions.h mavlink_helpers.h mavlink_types.h protocol.h
    app/Mavlink/TLE9879_MAVlink/: mavlink.h mavlink_msg_pmsm_command.h mavlink_msg_pmsm_status.h testsuite.h TLE9879_MAVlink.h version.h
